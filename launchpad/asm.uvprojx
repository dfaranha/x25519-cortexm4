# Keil uVision project asm.uvprojx, settings and files
target Launchpad (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: asm
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Content
    ./: main.c add.s copy.s cswap.s from_bytes.s sub.s to_bytes.s mul.s sqr.s mul121665.s invert.s scalarmult.s measuretiming.s
  group Device
    ./driverlib/: cpu.c gpio.c interrupt.c sysctl.c uart.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
